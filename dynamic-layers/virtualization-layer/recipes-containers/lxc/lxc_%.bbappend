PACKAGECONFIG_append = " seccomp"

