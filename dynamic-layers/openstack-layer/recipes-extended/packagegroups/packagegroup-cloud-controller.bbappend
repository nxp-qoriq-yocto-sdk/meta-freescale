RDEPENDS_${PN}_remove = "openvswitch-controller"
RDEPENDS_${PN}_append = "openvswitch-testcontroller"
