OPENSTACK_CONTROLLER_EXTRA_INSTALL_append_qoriq = "\
    apache2 \
    mariadb \
    memcached \
    mysql-python \
    rsync \
"
OPENSTACK_CONTROLLER_EXTRA_INSTALL_append_qoriq-ppc = "\
    openjdk-7-jre \
"
