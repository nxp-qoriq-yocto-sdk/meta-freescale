SRC_URI = "git://github.com/openstack/trove.git;branch=stable/kilo \
          file://trove-init \
          "

SRCREV="299d2de4fa1f46be8a023207568dbf81cd67b530"
PV="2015.1.2+git${SRCPV}"
