RDEPENDS_nscd_append = " bash"
