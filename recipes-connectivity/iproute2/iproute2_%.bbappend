EXTRA_OEMAKE_append_fsl-lsch3 = " SUBDIRS='lib tc ip bridge'"
