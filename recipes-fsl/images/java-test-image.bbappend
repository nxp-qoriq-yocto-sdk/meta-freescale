IMAGE_INSTALL_append_qoriq = "\
    openjdk-6-doc openjdk-6-demo openjdk-6-jdk \
    openjdk-7-doc openjdk-7-demo openjdk-7-jdk \
"
IMAGE_FSTYPES="tar.gz ext2.gz ext2.gz.u-boot"
