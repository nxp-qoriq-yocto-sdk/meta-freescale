ERROR_QA_remove_e6500 = "arch"
