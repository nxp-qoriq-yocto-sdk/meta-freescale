PACKAGECONFIG[bzip2] = "--enable-bzip2,--disable-bzip2,bzip2"
