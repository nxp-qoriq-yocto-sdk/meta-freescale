RDEPENDS_${PN}_append = " coreutils"
